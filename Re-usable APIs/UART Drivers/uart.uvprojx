# Keil uVision project uart.uvprojx, settings and files
target stm32f407 (6160000::V6.16::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main Application
    ./: main.c
  group High Level APIs
    ./: system.c system.h usart2.c usart2.h
  group Low Level APIs
    ./: clocks.c clocks.h gpio.c gpio.h systick.c systick.h uart.c uart.h
  group Generic
    ./: SysTimer_Struct.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
